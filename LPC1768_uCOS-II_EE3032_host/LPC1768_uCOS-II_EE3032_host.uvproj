# Keil uVision project LPC1768_uCOS-II_EE3032_host.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPC1768_uCOS-II_EE3032_host +hex
  c flags: Optim=1
  c include: .\src\CMSIS;.\src\uCOS-II\Ports;.\src\uCOS-II\Source;.\src\APP;.\src\library
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group CMSIS
    ./src/CMSIS/: core_cm3.c system_LPC17xx.c startup_LPC17xx.s
  group uCOS-II_Ports
    ./src/uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.s
  group uCOS-II_Source
    ./src/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group APP
    ./src/APP/: app_hooks.c
  group library
    ./src/library/: basic.c nrf24l01p.c nrf24l01p_port.c pin.c pwm.c spi.c uart0_pending.c usb.c usb_mouse.c sonar_rx.c
  group ee3032_host
    ./src/ee3032_host/: main.c task.c servo.c core.c geometry.c rgb.c
